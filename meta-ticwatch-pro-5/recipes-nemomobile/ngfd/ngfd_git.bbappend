RDEPENDS:${PN}:append:ticwatch-pro-5 = " ngfd-plugin-droid-vibrator "
