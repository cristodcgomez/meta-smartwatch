RDEPENDS:${PN}:append:ticwatch-pro-5 = " geoclue-provider-hybris-binder "
