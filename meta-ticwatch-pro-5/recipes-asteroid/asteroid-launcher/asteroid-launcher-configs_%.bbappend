FILESEXTRAPATHS:prepend:ticwatch-pro-5 := "${THISDIR}/asteroid-launcher-configs:"