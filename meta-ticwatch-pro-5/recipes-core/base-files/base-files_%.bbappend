FILESEXTRAPATHS:prepend:ticwatch-pro-5 := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:ticwatch-pro-5 = "ticwatch-pro-5"
